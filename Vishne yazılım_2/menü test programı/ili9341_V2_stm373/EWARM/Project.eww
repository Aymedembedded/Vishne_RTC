<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ili9341_V2_stm373.ewp</path>
  </project>
  <batchBuild />
</workspace>
